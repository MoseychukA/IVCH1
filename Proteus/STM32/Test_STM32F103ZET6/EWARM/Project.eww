<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Test_STM32F103ZET6.ewp</path>
  </project>
  <batchBuild />
</workspace>
