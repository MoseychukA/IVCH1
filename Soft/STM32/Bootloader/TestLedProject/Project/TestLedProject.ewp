# IAR project TestLedProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\SPL; ..\STM32F103_STARTUP\asm; ..\STM32F103_STARTUP\inc; ..\STM32F103_STARTUP\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TestLedProject.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ..\Linker\stm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group SPL
    ../SPL/: misc.c misc.h stm32f10x_conf.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_tim.c stm32f10x_tim.h system_stm32f10x.c
  group StartUp
    ../STM32F103_STARTUP/asm/: startup_stm32f10x_hd.s
